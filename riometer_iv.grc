<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>riometer_iv</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>max_nouts</key><value>128</value></param>
<param><key>title</key><value>CCERA Gen IV Riometer</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TEE_SKY</value></param>
<param><key>value</key><value>riometer_helper.estimate_Tsky(fast_pacer,ireftemp,itsys,itsys_ref,ilnagain,skyestimate,temp_commit)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tant_e</value></param>
<param><key>comment</key><value>Based on an empirical model of 
Sky Temp vs frequency</value></param>
<param><key>value</key><value>(riometer_helper.tsky_model(ifreq)/2.0)+290</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>anno_status</value></param>
<param><key>value</key><value>riometer_helper.annotate(prefix, ireftemp, itsys, ifreq, samp_rate, igain, itsys_ref, ilnagain, note)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ebw</value></param>
<param><key>value</key><value>"%d" % ((samp_rate/1.0e3)*0.87)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fast_pacer</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[-220.0]*fftsize</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>faultstate</value></param>
<param><key>value</key><value>"***FAULT***" if riometer_helper.get_fault(pacer) == True else "Normal"</value></param>
<param><key>gui_hint</key><value>main@2:6,2,1,1</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_prober</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[-220.0]*fftsize</value></param>
<param><key>poll_rate</key><value>poll_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_l1</value></param>
<param><key>value</key><value>firdes.low_pass(1.0,srate,samp_rate/2.15,samp_rate/8.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_l2</value></param>
<param><key>value</key><value>firdes.low_pass(1.0,samp_rate,samp_rate/2.25,samp_rate/20.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frate</value></param>
<param><key>value</key><value>int(samp_rate/fftsize)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ifreq</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>gui_hint</key><value>main@2:4,0,1,1</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>igain</value></param>
<param><key>value</key><value>rfgain</value></param>
<param><key>gui_hint</key><value>main@2:1,0,1,1</value></param>
<param><key>label</key><value>SKY RF Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>iimpulse</value></param>
<param><key>value</key><value>impulse</value></param>
<param><key>gui_hint</key><value>main@2:0,0,1,1</value></param>
<param><key>label</key><value>Impulse Holdoff Time (Secs)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ilnagain</value></param>
<param><key>value</key><value>lnagain</value></param>
<param><key>gui_hint</key><value>main@2:1,2,1,1</value></param>
<param><key>label</key><value>SKY LNA Gain (dB)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>impulse_count</value></param>
<param><key>value</key><value>int(poll_rate*iimpulse)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>irefgain</value></param>
<param><key>value</key><value>refgain</value></param>
<param><key>gui_hint</key><value>main@2:3,0,1,1</value></param>
<param><key>label</key><value>REF RF Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ireftemp</value></param>
<param><key>value</key><value>reftemp</value></param>
<param><key>gui_hint</key><value>main@2:3,2,1,1</value></param>
<param><key>label</key><value>Reference Noise Temp(K)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ithresh</value></param>
<param><key>value</key><value>thresh</value></param>
<param><key>gui_hint</key><value>main@2:0,1,1,1</value></param>
<param><key>label</key><value>Impulse Noise Threshold (dB)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>itsys</value></param>
<param><key>value</key><value>tsys</value></param>
<param><key>gui_hint</key><value>main@2:1,1,1,1</value></param>
<param><key>label</key><value>SKY Tsys (K)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>itsys_ref</value></param>
<param><key>value</key><value>tsysref</value></param>
<param><key>gui_hint</key><value>main@2:3,1,1,1</value></param>
<param><key>label</key><value>REF Tsys (K)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logstat</value></param>
<param><key>value</key><value>riometer_helper.logging(fast_pacer,reset_fault,prefix,ifreq,samp_rate,10,longitude)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>note</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>main@2:2,0,1,5</value></param>
<param><key>label</key><value>Observation Notes</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pacer</value></param>
<param><key>block_id</key><value>ref_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0]*fftsize</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>poll_rate</value></param>
<param><key>value</key><value>urate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>ref_prober</value></param>
<param><key>block_id</key><value>ref_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[1.0e-15]*fftsize</value></param>
<param><key>poll_rate</key><value>poll_rate</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>reset_fault</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main@2:6,0,1,1</value></param>
<param><key>label</key><value>Reset Antenna Fault</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>reset_peak</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main@0:4,0,1,1</value></param>
<param><key>label</key><value>Reset Peak Hold</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>srate/decim</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>skyestimate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main@2:5,0,1,1</value></param>
<param><key>label</key><value>Sky Noise Estimate (dB ENR)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>temp_commit</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main@2:5,1,1,1</value></param>
<param><key>label</key><value>Apply Sky Temp Estimate</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>riometer_helper.impulses(pacer)</value></param>
<param><key>gui_hint</key><value>main@2:0,2,1,1</value></param>
<param><key>label</key><value>Impulse Events</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>win</value></param>
<param><key>value</key><value>fft.window.blackmanharris(fftsize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>winsum</value></param>
<param><key>value</key><value>sum(map(lambda x:x*x, win))</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>riometer_helper.signal_evaluator(fft_prober,prefix,ithresh,impulse_count,poll_rate)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>comment</key><value>This gets updated at 1Hz with a derived
  Sky noise temperature estimate</value></param>
<param><key>const</key><value>riometer_helper.chart_Tsky(pacer,3600)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3600</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0_0</value></param>
<param><key>comment</key><value>What the Tsky *should* roughly be, according
to models.</value></param>
<param><key>const</key><value>[Tant_e]*3600</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3600</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0_0_0</value></param>
<param><key>comment</key><value>1-minute data, spanning 24 hours</value></param>
<param><key>const</key><value>riometer_helper.minute_data(pacer)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1440</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_1</value></param>
<param><key>const</key><value>riometer_helper.do_reference(ref_prober,poll_rate)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_1_0</value></param>
<param><key>const</key><value>riometer_helper.handle_peak_hold(fft_prober,reset_peak,poll_rate)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>frate/10</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>frate/10</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>[0]*fftsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>k</key><value>-20*math.log10(fftsize)-10.0*math.log10(winsum/fftsize)-20*math.log10(1)</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>k</key><value>-20*math.log10(fftsize)-10.0*math.log10(winsum/fftsize)-20*math.log10(1)</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>1440</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>3600</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>1440*2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1440</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>3600*2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3600</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>512</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0</value></param>
<param><key>length</key><value>512</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>label</key><value>Input Decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Input Device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=0 file=/dev/zero,rate=5.0e6</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>filter_l1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter_l2</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter_l2</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_1</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>filter_l1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>win</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>win</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>foo</value></param>
<param><key>stream_id</key><value>fftmags</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30e6</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>impulse</value></param>
<param><key>label</key><value>Impulse Noise Holdoff Time (Secs)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lnagain</value></param>
<param><key>label</key><value>Gain of SKY side LNA</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>longitude</value></param>
<param><key>label</key><value>Local longitude</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-76.03</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>main</value></param>
<param><key>gui_hint</key><value>0,0,1,5</value></param>
<param><key>label0</key><value>Real Time</value></param>
<param><key>label1</key><value>Daily</value></param>
<param><key>label2</key><value>Parameters</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Make zeros at the same rate as
the FFTs</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>ifreq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>igain</value></param>
<param><key>bb_gain1</key><value>20</value></param>
<param><key>dc_offset_mode1</key><value>2</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>ifreq+25e3</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>if_gain1</key><value>20</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>gain1</key><value>irefgain</value></param>
<param><key>comment</key><value>REF side is tuned slightly away
from SKY side, to prevent any
possible LO beating</value></param>
<param><key>args</key><value>device</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>srate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>File prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>main@0:0,0,2,5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Raw Sky</value></param>
<param><key>label2</key><value>Excised (+15dB)</value></param>
<param><key>label3</key><value>Reference</value></param>
<param><key>color4</key><value>"dark red"</value></param>
<param><key>label4</key><value>Peak Hold</value></param>
<param><key>name</key><value>"Raw and Excised Spectrum: Effective Bw=" + str(ebw)+"kHz"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>Frequency (MHz)</value></param>
<param><key>x_start</key><value>(ifreq-(samp_rate/2.0))/1.0e6</value></param>
<param><key>x_step</key><value>(samp_rate/fftsize)/1.0e6</value></param>
<param><key>x_units</key><value>MHz</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-100</value></param>
<param><key>y_axis_label</key><value>dB</value></param>
<param><key>y_units</key><value>dB</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>gui_hint</key><value>main@0:5,0,2,5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Sky Noise Temp(K)</value></param>
<param><key>color2</key><value>"dark red"</value></param>
<param><key>label2</key><value>Model (K)</value></param>
<param><key>width2</key><value>2</value></param>
<param><key>name</key><value>Apparent Sky Noise Temperature (K)</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.25</value></param>
<param><key>vlen</key><value>3600</value></param>
<param><key>x_axis_label</key><value>Time (Minutes)</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0/60.0</value></param>
<param><key>x_units</key><value>Mins</value></param>
<param><key>ymax</key><value>Tant_e*2.0</value></param>
<param><key>ymin</key><value>Tant_e/2.0</value></param>
<param><key>y_axis_label</key><value>Noise Temp(K)</value></param>
<param><key>y_units</key><value>K</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_1</value></param>
<param><key>gui_hint</key><value>main@1:0,0,1,5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>60s avg</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>name</key><value>Daily 60-second Sky Temperature</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>1.0</value></param>
<param><key>vlen</key><value>1440</value></param>
<param><key>x_axis_label</key><value>"Time (Hours)"</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1/60.0</value></param>
<param><key>x_units</key><value>"Hours"</value></param>
<param><key>ymax</key><value>Tant_e*2.0</value></param>
<param><key>ymin</key><value>Tant_e/2.0</value></param>
<param><key>y_axis_label</key><value>"Noise Temp (K)"</value></param>
<param><key>y_units</key><value>"K"</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>ref_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>refgain</value></param>
<param><key>label</key><value>Reference Gain Level</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>reftemp</value></param>
<param><key>label</key><value>Reference Noise  Temperature Estimate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>297</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30.0</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>riometer_helper</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import time
import math
import numpy
import random
import ephem

#
# Store the averaged/integrated FFT results (post-excision) here
#
avg_fft = [0.0]*128

#
# Keep track of the most recent post-excision, pre-integration
#  output, for impulse blanking.
#
last_out = [0.0]*128


#
# An event counter for impulse events that are getting
#  (partially, at least) suppressed
#
impulse_events = 0

#
# A counter/timer for hold-off for impulse detection
#
impulse_count = 0


#
# Statistical counters, etc
#
exceeded_ocount = [0]*128
exceeded_mtime = [0.0]*128
exceeded_delta = [0.0]*128

#
# For fuzzing during impulse-blanking
#
fuzz_buffer_01 = [0.1]*128
fuzz_buffer_04 = [0.4]*128

#
# Cached alpha value for excised FFT
#
ealpha = -200.0
#
# Evaluate signal (as fft), and perform spectral excision
#  and impulse removal, calculate current total-power estimate
#  after all that has been done.
#
# Keep stats on these events
#
#
# It handles both types of excision, and keeps track of stats
#
def signal_evaluator(infft,prefix,thresh,duration,prate):
    global avg_fft
    global last_out
    global impulse_count
    global impulse_events
    global exceeded_ocount
    global exceeded_mtime
    global exceeded_delta
    global ealpha
    global fuzz_buffer_01
    global fuzz_buffer_04
    
    #
    # We cache an alpha value, just so we don't have to do this
    #   gnarly math at prate
    #
    if (ealpha &lt; 0.0):
        ealpha = 1.0-(math.pow(math.e,-2*(3.0/prate)))
    beta = 1.0-ealpha
    
    #
    # (re)init fuzz buffers either
    #  because they are too small, or we want to randomly
    #  refresh them.
    # The random() functions aren't particularly speedy, so we
    #   only want to call them 'sometimes'.  So, we arrange for there
    #   to be a probability of 0.2 that we'll refresh the fuzz buffers
    #
    if ((len(fuzz_buffer_01) &lt; len(infft)) or (random.randint(0,5) == 0)):
        fuzz_buffer_01 = [0.0]*len(infft)
        fuzz_buffer_04 = [0.0]*len(infft)
        
        for i in range(0,len(infft)):
            fuzz_buffer_01[i] = random.uniform(-0.1,0.1)
            fuzz_buffer_04[i] = random.uniform(-0.4,0.4)

    #
    # We build a dict of quantized-to-one-dB
    #   FFT bin values
    #
    # We count the occurence, and use the largest two
    #   as the "mode" of the dataset
    #
    dbdict = {}
    for v in infft:
        key = int(v)
        if key in dbdict:
            dbdict[key] += 1
        else:
            dbdict[key] = 1
    
    #
    # Not quite ready
    #
    if (infft[0] == -220.0 and infft[1] == -220.0):
        return ([-80.0]*len(infft))
    
    #
    # Sort the list by values
    # Returning the "keys" which are the quantized dB values
    #
    slist = sorted(dbdict, key=dbdict.__getitem__)
    
    #
    # We estimate the "mode" by taking the top two values
    #  (top two most-frequent quantized dB values), we
    #  slightly bias the most-frequent value
    #
    mode = slist[len(slist)-1]*1.2
    mode += slist[len(slist)-2]*0.8
    mode /= 2.0
    
    mode = float(mode)
    
    
    #
    # Setup for mode-based excision
    #
    outfft = [0.0]*len(infft)
    indx = 0
    
    #
    # Re-size if necessary
    #
    if (len(exceeded_ocount) != len(infft)):
        exceeded_ocount = [0]*len(infft)
        exceeded_mtime = [0.0]*len(infft)
        exceeded_delta = [0.0]*len(infft)
    
    #
    # Anything that exceeds the mode estimate by 1.5dB or more,
    #  we "smooth".
    #
    now = time.time()
    for v in infft:
        if (v-mode &gt;= 1.5):
            outfft[indx] = mode+fuzz_buffer_04[indx]
            
            #
            # "Fresh" excision event
            #
            if ((now - exceeded_mtime[indx]) &gt;= 5.0):
                exceeded_delta[indx] = now - exceeded_mtime[indx]
                exceeded_mtime[indx] = now
                exceeded_ocount[indx] += 1
        else:
            outfft[indx] = v
        indx += 1
    
    #
    # Handle buffer init/resize
    #
    if (len(avg_fft) != len(outfft)):
        avg_fft = list(outfft)
        last_out = list(outfft)
    
    #
    # Try to detect impulse noise, and reject it
    # If we aren't in the middle of an impulse event holdoff period,
    #    check for impulse (value exceeds threshold)
    #
    exceeded_bins = 0
    if (impulse_count &lt;= 0):
        for i in range(0,len(outfft)):
            if (abs(outfft[i]-last_out[i]) &gt; thresh):
                exceeded_bins += 1
        #
        # If more than 25% of the bins are in "exceeded" state
        #   declare an impulse-noise event
        #
        if (exceeded_bins &gt;= (len(outfft)/4.0)):
            impulse_count = duration
            impulse_events += 1
    #
    # Update averages, etc only if we aren't in an impulse-noise
    #    blanking interval
    #
    
    if (impulse_count &lt;= 0):
        #
        # Do single-pole IIR filter
        #
        new_fft = numpy.multiply(outfft,[ealpha]*len(outfft))
        avg_fft = numpy.add(new_fft, numpy.multiply(avg_fft,[beta]*len(outfft)))
    
    #
    # This will cause us to frob on avg_fft with P = 0.25
    #
    elif (random.randint(0,4) == 0):
        
        #
        # First, fold-in fuzz buffer
        new_fft = numpy.add(avg_fft, fuzz_buffer_01)
        avg_fft = numpy.add(new_fft, avg_fft)
        avg_fft = numpy.divide(avg_fft, [2.0]*len(avg_fft))
        
        #
        # Then fold-in a tiny contribution from current data
        #
        diff = numpy.sub(avg_fft, last_out)
        diff = numpy.add(avg_fft, numpy.multiply(diff,[0.0025]*len(diff)))
        avg_fft = numpy.divide(diff, [2.0]*len(avg_fft))
    
    #
    # Always record the last excised FFT buffer
    #
    last_out = list(outfft)
    
    #
    # Decrement impulse holdoff counter if necessary
    #
    if (impulse_count &gt; 0):
        impulse_count -= 1

    #
    # For display purposes only, bump the excised value up by 15dB
    #  so that it constrasts with the input enough to be clear
    #
    outfft = numpy.add(avg_fft, [15.0]*len(avg_fft))
    
    #
    # Compute the total power across avg_fft
    #
    pvect = numpy.multiply(avg_fft, [0.1]*len(avg_fft))
    pvect = numpy.power([10.0]*len(avg_fft),pvect)
    pwr = numpy.sum(pvect)
    
    #
    # Other subsystems need to know current value of pwr
    #
    set_current_pwr(pwr)
    
    return (outfft)

def get_avg_fft():
    global avg_fft
    
    return (avg_fft)

def get_exceeded_ocount():
    global exceeded_ocount
    
    return (exceeded_ocount)

def get_exceeded_delta():
    global exceeded_delta
    
    return(exceeded_delta)

def cur_sidereal(longitude):
    longstr = "%02d" % int(longitude)
    longstr = longstr + ":"
    longitude = abs(longitude)
    frac = longitude - int(longitude)
    frac *= 60
    mins = int(frac)
    longstr += "%02d" % mins
    longstr += ":00"
    x = ephem.Observer()
    x.date = ephem.now()
    x.long = longstr
    jdate = ephem.julian_date(x)
    tokens=str(x.sidereal_time()).split(":")
    hours=int(tokens[0])
    minutes=int(tokens[1])
    seconds=int(float(tokens[2]))
    sidt = "%02d,%02d,%02d" % (hours, minutes, seconds)
    return (sidt)
#
# For keeping track of logging at regular intervals
#
last_time = time.time()
seconds = 0
fast_data_pHz = [0.0]*100
fast_data_ndx = 0
def logging(infft,renormal,prefix,freq,bw,prate,longitude):

    global seconds
    global last_time
    global fast_data_pHz
    global fast_data_ndx
    
    #
    # Resize fast_data_pHz if necessary
    #
    if (len(fast_data_pHz) != prate):
        fast_data_pHz = [[0.0,0.0]]*prate
    
    #
    # We record fast data in a buffer, and that buffer only gets logged once per second
    #
    fast_data_pHz[fast_data_ndx % prate] = [get_current_pwr(), get_refval()]
    
    #
    # It heads off to infinity
    #
    fast_data_ndx += 1
    
    #
    # Update the seconds counter
    #
    if ((time.time() - last_time) &gt;= 1.0):
        last_time = time.time()
        seconds += 1
        
        #
        # Pickup system time
        #
        ltp = time.gmtime(time.time())
        
        hdr_format = "%02d,%02d,%02d,%s,%d,%d,"
        hdr_contents = (ltp.tm_hour, ltp.tm_min, ltp.tm_sec, cur_sidereal(longitude), freq, bw)
        hdr = hdr_format % hdr_contents

        #
        # Power estimates
        #
        #
        # Every second
        #
        if (seconds != 0 and (seconds % 1 == 0)):
            #
            # Time to check on possible antenna faults
            #
            handle_normal_power(get_current_pwr(),renormal)
            
            #
            # Derive 1sec reference value from fast_pHz values
            #
            r = 0.0
            for v in fast_data_pHz:
                r += v[1]
            
            #
            # Reduce to average
            #
            r /= len(fast_data_pHz)
            
            
            #
            # Implement a median filter for SKY data
            #
            
            #
            # First extract SKY values from fast_data_pHz
            #
            sortedp = [x[0] for x in fast_data_pHz]
            
            #
            # Then sort
            #
            sortedp = sorted(sortedp)
            
            #
            # Pull the mid 3 values and average them
            #
            p = sortedp[len(sortedp)/2]
            p += sortedp[len(sortedp)/2+1]
            p += sortedp[len(sortedp)/2-1]
            p /= 3.0
            
            #
            # Tweak reference value so that div-by-zero doesn't
            #   happen
            
            rv = r
            if (rv == 0.0):
                rv = 1.0e-15
            
            #
            # Do recording of powers/temps
            #
            handle_pwr_recording(p, rv, hdr, ltp, prefix, fast_data_pHz)
        #
        # Spectral
        #
        # Every 60 seconds
        #
        if (seconds != 0 and (seconds % 60 == 0)):
            handle_spec_recording(infft,"spec-raw", ltp, hdr, prefix)
            handle_spec_recording(get_avg_fft(), "spec-excised", ltp, hdr, prefix)
            handle_spec_recording(get_peakhold(), "spec-peak", ltp, hdr, prefix)
            handle_spec_recording(get_exceeded_ocount(), "spec-ecounts", ltp, hdr, prefix)
            handle_spec_recording(get_exceeded_delta(), "spec-edeltas", ltp, hdr, prefix)
#
# A buffer for the averaged reference FFT
#
avg_rfft = [-220.0]*128

#
# Cached alpha value
#
ralpha = -200.0

#
# Process the reference-side FFT
#
def do_reference(ref_fft,prate):
    global avg_rfft
    global ralpha
    
    if (ralpha &lt; 0.0):
        ralpha = 1.0-math.pow(math.e,-2*(0.5/prate))
    beta = 1.0-ralpha
    
    #
    # Handle re-size
    #
    if (len(avg_rfft) != len(ref_fft)):
        avg_rfft = list(ref_fft)
    
    #
    # Single-pole IIR filter it
    #
    tfft = numpy.multiply([ralpha]*len(ref_fft),ref_fft)
    avg_rfft = numpy.add(tfft,numpy.multiply([beta]*len(avg_rfft),avg_rfft))
    
    #
    # Compute reference level from FFT data
    #
    pvect = numpy.multiply(ref_fft, [0.1]*len(ref_fft))
    pvect = numpy.power([10.0]*len(ref_fft),pvect)
    set_refval((ralpha*numpy.sum(pvect))+(beta*refval))
    return avg_rfft

#
# A buffer for the converted-to-kelvin stripchart display
#
stripchart = [0.0]*128

def chart_Tsky(pace,siz):
    global stripchart
    
    if (len(stripchart) != siz):
        stripchart = [0.0]*siz

    #
    # Shift chart, place new value
    #
    stripchart = [get_Tsky()]+stripchart[0:len(stripchart)-1]

    return (stripchart)

#
# Pretty much what the name suggests
#
def estimate_Tsky(pace,reftemp,tsys,tsys_ref,lnagain,estimate,commit):
    
    #
    # Need to find Sky temp that satisfies:
    #
    # ratio = (Tsky+Tsys)/(Tsys_ref+reftemp)
    # X = (Tsys_ref+reftemp)
    # ratio*X = (Tsky+Tsys)
    # (ratio*X)-Tsys = Tsky
    #
    # We know the ratio from actual measurements,
    #  and all the other parameters except Tsky
    #  are available as fixed parameters (guesstimates from
    #  user input).
    #
    #
    X = tsys_ref+reftemp
    
    rv = get_refval()
    if (rv == 0):
        rv += 1.0e-15
    
    pwr = get_current_pwr()
    
    tsky = ((pwr/rv)*X)-tsys
    
    #
    # We divide the apparent Tsky by any LNA gain that may be behind it,
    #  but not in-common with the REF side of the house.
    #
    tsky /= math.pow(10.0, lnagain/10.0)
    
    #
    # This can be used to "tweak" the sky-side estimate, using an
    #  external calibrator source.  User enters CAL noise value, in dB ENR.
    #
    # This only really works well if the other parameters have been "dialed in"
    #   fairly well.
    #
    if (estimate &gt; 0.0 and commit != 0):
        #
        # Convert from dB ENR to temperature
        #
        estimate = math.pow(10.0,estimate/10.0)
        estimate *= 297.0
        set_skyratio(estimate/tsky)

    #
    # Adjust by tweakage ratio
    #
    tsky = tsky * get_skyratio()
    set_Tsky(tsky)  
    return (get_Tsky())

def annotate(prefix, reftemp, tsys, freq, bw, gain, itsys_ref, lnagain, notes):
    fn = prefix+"annotation-"
    ltp = time.gmtime(time.time())
    
    fn += "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    fn += ".csv"
    
    fp = open(fn, "a")
    fp.write("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
    fp.write("%.1f,%.1f," % (reftemp, tsys))
    fp.write("%.1f,%.1f,%.1f," % (freq, bw, gain))
    fp.write("%.1f,%.1f" % (itsys_ref, lnagain))
    fp.write("%s\n" % notes)
    fp.close()


#
# Because this little model is so damned useful
#
# We use it for automatically scaling the Sky temperature display
#  (Assuming, of course, that all the other algebra is correct)
#
def tsky_model(freq):
    a = ((freq/1.0e6)/39.0)
    a = math.pow(a,-2.55)
    a *= 9120.0
    return a

#
# A different strip-chart that shows 24 hours worth of data, updated once per
#   minute
#
DAILY_MINUTES=1440
minutes_chart = [0.0]*DAILY_MINUTES
mtsky = -1
mcounter = 0
def minute_data(p):
    global minutes_chart
    global mtsky
    global mcounter
    
    mtsky += get_Tsky()
    mcounter += 1
    if ((mcounter % 60) == 0):
        mtsky /= 60.0
        minutes_chart = [mtsky]+minutes_chart[0:DAILY_MINUTES-1]
        mtsky = 0.0

    return minutes_chart

def impulses(p):
    return impulse_events

astate = False   
def antenna_fault(state):
    global astate
    afault = state

def get_fault(p):
    global astate
    return astate

#
# Keep track of peak-hold data, both for logging, and display
#
peakhold = [0.0]*128

#
# For auto-peak-reset on startup (in ticks)
#
auto_rst = 100
auto_init = False

def handle_peak_hold(fft,rst,ticks):
    global auto_rst
    global peakhold
    global auto_init
    
    #
    # Setup inital auto_rst value
    #
    if (auto_init == False):
        auto_rst = 10*ticks
        auto_init = True

    #
    # Resize if necessary
    #
    if (len(peakhold) &lt; len(fft)):
        peakhold = list(fft)
        
    #
    # If they pushed the "Reset Peak Hold" button in the UI, OR
    #   The auto-rst variable has dropped through zero
    #
    auto_rst -= 1
    if (rst or (auto_rst == 0)):
        peakhold = list(fft)
    
    #
    # Do the peak-hold math
    #
    for i in range(0,len(peakhold)):
        if (fft[i] &gt; peakhold[i]):
            peakhold[i] = fft[i]
    
    return (peakhold)

def get_peakhold():
    global peakhold
    
    return(peakhold)

#
# For auto normal_power setting (in seconds)
#
auto_normal = 30

#
# Expected power level -- for fault detection
#
normal_power = -1.0

def handle_normal_power(pwr,renormal):
    global auto_normal
    global normal_power
    
    #
    # Set "normal power level" after "auto_normal" has timed out
    #
    auto_normal -= 1
    if (auto_normal == 0):
        normal_power = pwr
        antenna_fault(False)

    #
    # Reset possible fault
    #
    if (renormal):
        normal_power = pwr
        antenna_fault(False)
    
    #
    # Try to detect a significant drop in antenna power, and
    #   declare a probably antenna fault
    #
    if (pwr &lt; (normal_power/3.5)):
        antenna_fault(True)
    else:
        antenna_fault(False)

def handle_pwr_recording(pwr,rv,hdr,ltp,prefix,fdata):
    #
    # Record data in a daily file
    #
    fn = prefix+"rio-"
    fn += "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    fn += ".csv"

    fp = open(fn, "a")
    fp.write (hdr)
    fp.write ("%.7f,%.7f,%.7f,%e,%.1f\n" % (pwr, rv, pwr-rv, pwr/rv, get_Tsky()))
    fp.close()
    
    #
    # Record fast data as well
    #
    fn = prefix+"fast-"
    fn += "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    fn += ".csv"
    fp = open(fn, "a")
    fp.write(hdr)
    for v in fdata:
        fp.write ("(%.7f,%.7f)," % (v[0], v[1]) )
    fp.write("\n")
    fp.close()
    

def handle_spec_recording(fft,variant,ltp,hdr,prefix):
    #
    # Spectral-type data
    #
    fn = prefix+variant+"-"
    fn += "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    fn += ".csv"
    
    fp = open(fn, "a")
    fp.write(hdr)
    for v in fft:
        fp.write("%.3f," % v)
    fp.write("\n")
    fp.close()
    

#
# The current ratio between SKY and REF
#
current_ratio = 1.0

#
# Current pwr value
#
current_pwr = 0.0
def set_current_pwr(p):
    global current_pwr
    
    current_pwr = p

def get_current_pwr():
    global current_pwr
    
    return (current_pwr)
    
#
# Current reference value
#
refval = -1.0

def get_refval():
    global refval
    
    return(refval)

def set_refval(r):
    global refval
    
    refval = r

#
# The current Tsky estimate
#
Tsky = 100.0

def set_Tsky(t):
    global Tsky
    
    Tsky = t

def get_Tsky():
    global Tsky
    
    return(Tsky)


#
# We can use this to "force" a known calibration point using the UI
#
# For example, if the user plugs in a 10,000K noise source, and
#  Tsky is only reading 5000, this can be used to instantaneously
#  calculate an adjustment factor
#
skyratio = 1.0

def get_skyratio():
    global skyratio
    
    return (skyratio)

def set_skyratio(r):
    global skyratio
    
    skyratio = r

</value></param>
<param><key>comment</key><value>-- Data logging
-- RFI excision
-- Conversion to noise temps
-- Frequency vs sky noise model
-- Antenna fault evaluation
-- Excision statistics tracking</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0-math.pow(math.e,-2.0*(1.0/frate))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>alpha</key><value>1.0-math.pow(math.e,-2.0*(1.0/frate))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>910e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>thresh</value></param>
<param><key>label</key><value>Impulse Threshold (dB)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tsys</value></param>
<param><key>label</key><value>System Noise Temperature Estimate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1300</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tsysref</value></param>
<param><key>label</key><value>System Noise Temperature Estimate for REF</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1300</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>urate</value></param>
<param><key>label</key><value>Internal Update Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>decimags</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>f_ref</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>f_sky</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>rfftmags</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>zeros</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5</value></param>
<param><key>stream_id</key><value>const0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>f_ref</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>fftmags</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>decimags</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>f_sky</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>rfftmags</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5</value></param>
<param><key>stream_id</key><value>const0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5_0_0</value></param>
<param><key>stream_id</key><value>zeros</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>virtual_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_1_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>foo</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>fft_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0_0</source_block_id><sink_block_id>ref_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_1</source_block_id><sink_block_id>fft_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>blocks_stream_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
